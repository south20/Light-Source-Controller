# Keil uVision project UV_Master.uvprojx, settings and files
target UV_MasterA (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F767IITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: UV_Master +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F767xx,
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F7xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\PCF8574;..\HARDWARE\CAN;..\USMART;..\canfestival\inc;..\canfestival\inc\stm32;..\canfestival\hardware;..\canfestival_can;..\canfestival_timer;..\canfestival_master;..\IO;..\AP;..\PE;..\HARDWARE\EXTI;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f7xx_it.c system_stm32f7xx.c
  group CORE
    ../CORE/: core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f767xx.s
  group HALLIB
    ../HALLIB/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sram.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_can.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/LCD/: lcd.c ltdc.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/PCF8574/: pcf8574.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/TIMER/: timer8.c
  group USMART
    ../USMART/: usmart.c usmart_str.c usmart_config.c
  group README
    ../: readme.txt
  group canfestival
    ../canfestival/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c pdo.c objacces.c sdo.c states.c sync.c timer.c
    ../canfestival_timer/: canfestival_timer.c
    ../canfestival_can/: canfestival_can.c
    ../canfestival_master/: canfestival_master.c
  group IO
    ../IO/: IO_GPIO.c IO_ADC.C IO_ETHERNET.c IO_UART.c IO_encoder.c IO_DS1821.c
  group PE
    ../PE/: PE_GE.c PE_Light.c PE_Motor.c PE_BlowerFan.c PE_Get_GPIO_Sensor.c PE_HaloDisplay.c PE_KeyFunctions.c PE_LevelFunctions.c
  group AP
    ../AP/: AP_GE.c
